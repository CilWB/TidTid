# Keil uVision project TidTid02.uvprojx, settings and files
target TidTid02 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: TidTid02 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_HAL_DRIVER,STM32F746xx
  c include: ../FATFS/Target;  ../FATFS/App;  ../Core/Inc;  ../TouchGFX/target;  ../TouchGFX/generated/fonts/include;  ../TouchGFX/generated/texts/include;  ../TouchGFX/generated/images/include;  ../TouchGFX/generated/gui_generated/include;  ../TouchGFX/gui/include;../middlewares/st/touchgfx/touchgfx/framework/include;  ../Drivers/STM32F7xx_HAL_Driver/Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FatFs/src;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;  ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;  ../Drivers/CMSIS/Include;../middlewares/st/touchgfx/touchgfx/framework/include;  ..\Drivers\BSP;  ..\Drivers\BSP\STM32746G-Discovery;  ..\Drivers\BSP\Components\ft5336;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;  ..\Drivers;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Drivers/: pgmspace.h
    ../Core/Src/: main.cpp freertos.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7TouchController.cpp STM32F7Instrumentation.cpp HW_Init.cpp
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/TouchGFX
    ../middlewares/st/touchgfx/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Application/User/TouchGFX/gui
    ../touchgfx/gui/src/alarmmmmm_screen/: alarmmmmmpresenter.cpp alarmmmmmview.cpp
    ../touchgfx/gui/src/alarm_screen/: alarmpresenter.cpp alarmview.cpp
    ../touchgfx/gui/src/calendar_screen/: calendarpresenter.cpp calendarview.cpp
    ../touchgfx/gui/src/count_down_screen/: count_downpresenter.cpp count_downview.cpp
    ../touchgfx/gui/src/count_up_screen/: count_uppresenter.cpp count_upview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/main_screen/: mainpresenter.cpp mainview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/screen2_screen/: screen2presenter.cpp screen2view.cpp
  group Application/User/TouchGFX/generated
    ../touchgfx/generated/gui_generated/src/alarmmmmm_screen/: alarmmmmmviewbase.cpp
    ../touchgfx/generated/gui_generated/src/alarm_screen/: alarmviewbase.cpp
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp font_digitalt_19_4bpp.cpp font_digitalt_20_4bpp.cpp font_digitalt_29_4bpp.cpp font_digitalt_30_4bpp.cpp font_digitalt_90_4bpp.cpp font_impact_20_4bpp.cpp font_opensans_bold_20_4bpp.cpp font_segoeuib_16_4bpp.cpp font_segoeuib_18_4bpp.cpp fontgetters.cpp kerning_digitalt_19_4bpp.cpp kerning_digitalt_20_4bpp.cpp kerning_digitalt_29_4bpp.cpp kerning_digitalt_30_4bpp.cpp kerning_digitalt_90_4bpp.cpp kerning_impact_20_4bpp.cpp kerning_opensans_bold_20_4bpp.cpp kerning_segoeuib_16_4bpp.cpp kerning_segoeuib_18_4bpp.cpp table_digitalt_19_4bpp.cpp table_digitalt_20_4bpp.cpp table_digitalt_29_4bpp.cpp table_digitalt_30_4bpp.cpp table_digitalt_90_4bpp.cpp table_impact_20_4bpp.cpp table_opensans_bold_20_4bpp.cpp table_segoeuib_16_4bpp.cpp table_segoeuib_18_4bpp.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp butdown.cpp butup.cpp down.cpp down1.cpp down2.cpp down_r.cpp down_r2.cpp downn.cpp downnnn.cpp group2823.cpp group2824.cpp reset.cpp reset1.cpp save.cpp save2.cpp snooze.cpp snooze2.cpp start.cpp start1.cpp stop.cpp stop1.cpp stst.cpp stt.cpp stts.cpp sttsst.cpp sttt.cpp up.cpp up1.cpp up2.cpp up_r.cpp up_r2.cpp upp.cpp uppp.cpp
    ../touchgfx/generated/images/src/__designer/: blue_buttons_round_icon_button.cpp blue_buttons_round_icon_button_pressed.cpp blue_buttons_square_icon_button.cpp blue_buttons_square_icon_button_pressed.cpp blue_slider_horizontal_medium_indicators_slider_round_edge_nob.cpp blue_slider_horizontal_medium_slider_round_edge_back.cpp blue_slider_horizontal_medium_slider_round_edge_fill.cpp
    ../touchgfx/generated/gui_generated/src/calendar_screen/: calendarviewbase.cpp
    ../touchgfx/generated/gui_generated/src/count_down_screen/: count_downviewbase.cpp
    ../touchgfx/generated/gui_generated/src/count_up_screen/: count_upviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_screen/: mainviewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/screen2_screen/: screen2viewbase.cpp
  group Drivers/BSP
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_qspi.c stm32746g_discovery_ts.c
software components: CMSIS:CORE 4.3.0
